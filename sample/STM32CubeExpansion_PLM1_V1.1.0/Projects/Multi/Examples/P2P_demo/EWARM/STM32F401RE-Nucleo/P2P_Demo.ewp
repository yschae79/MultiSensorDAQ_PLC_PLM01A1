# IAR project P2P_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STM32F4XX_NUCLEO; USE_HAL_DRIVER; STM32F401xE; NO_EEPROM; P2P_DEMO; ST7580_ST_SHIELD; STM32F4
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-PLM01A1; ..\..\..\..\..\..\Drivers\BSP\Components\ST7580\ST7580_Library\Inc; ..\..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F401RE-Nucleo_P2P_PLM01A1.bin
  ILINK.IlinkOutputFile: P2P_Demo.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xe.s
  group Application/USER
    ../../Src/: cube_hal_f4.c main.c st7580_appli.c stm32f4xx_it.c
  group Doc
    ../../: readme.txt
  group Driver/BSP/Components/ST7580/ST7580_Driver/ST7580_Library
    ../../../../../../Drivers/BSP/Components/ST7580/ST7580_Library/Src/: ST7580_Serial.c
  group Driver/BSP/STM32F4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo/: stm32f4xx_nucleo.c
  group Driver/BSP/X_NUCLEO-PLM01A1
    ../../../../../../Drivers/BSP/X-NUCLEO-PLM01A1/: stm32_plm01a1.c
  group Driver/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Driver/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c
