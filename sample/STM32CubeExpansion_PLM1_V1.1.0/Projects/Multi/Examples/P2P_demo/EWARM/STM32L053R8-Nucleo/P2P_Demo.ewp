# IAR project P2P_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER; STM32L053xx; NO_EEPROM; P2P_DEMO; ST7580_ST_SHIELD; STM32L0
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-PLM01A1; ..\..\..\..\..\..\Drivers\BSP\Components\ST7580\ST7580_Library\Inc; ..\..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L053R8-Nucleo_P2P_PLM01A1.bin
  ILINK.IlinkOutputFile: P2P_Demo.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/iar/: startup_stm32l053xx.s
  group Application/USER
    ../../Src/: cube_hal_l0.c main.c st7580_appli.c stm32l0xx_it.c
  group Doc
    ../../: readme.txt
  group Driver/BSP/Components/ST7580/ST7580_Driver/ST7580_Library
    ../../../../../../Drivers/BSP/Components/ST7580/ST7580_Library/Src/: ST7580_Serial.c
  group Driver/BSP/STM32L0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Driver/BSP/X_NUCLEO-PLM01A1
    ../../../../../../Drivers/BSP/X-NUCLEO-PLM01A1/: stm32_plm01a1.c
  group Driver/CMSIS
    ../../Src/: system_stm32l0xx.c
  group Driver/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
