# Keil uVision project P2P_Demo.uvprojx, settings and files
target ST7580-Point-To-Point (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32L053R8-Nucleo_P2P +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=..\..\Binary\STM32L053R8-Nucleo\STM32L053R8-Nucleo_P2P.bin Listing\STM32L053R8-Nucleo_P2P.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER,STM32L053xx,NO_EEPROM,P2P_DEMO
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-PLM01A1\;..\..\..\..\..\..\Drivers\BSP\Components\st7580\St7580_Library\Inc;..\..\..\..\..\..\..\Utilities
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Src/: system_stm32l0xx.c
  group Application/User
    ../../Src/: main.c st7580_appli.c cube_hal_l0.c stm32l0xx_it.c
  group Docs
    ../../: readme.txt
  group Drivers/BSP/X-NUCLEO-PLM01A1
    ../../../../../../Drivers/BSP/X-NUCLEO-PLM01A1/: stm32_plm01a1.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l053xx.s
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Drivers/BSP/Components/ST7580/ST7580_Library
    ../../../../../../Drivers/BSP/Components/ST7580/ST7580_Library/Src/: ST7580_Serial.c
