# Keil uVision project P2P_Demo.uvprojx, settings and files
target ST7580-Point-To-Point (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F401RE-Nucleo_P2P +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=..\..\Binary\STM32F401RE-Nucleo\STM32F401RE-Nucleo_P2P.bin Listing\STM32F401RE-Nucleo_P2P.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STM32F4XX_NUCLEO,USE_HAL_DRIVER,STM32F401xE,NO_EEPROM,P2P_DEMO,SPIRIT1_ST_SHIELD,USE_SPIRIT1_DEFAULT
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\Components\st7580\St7580_Library\Inc;..\..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-PLM01A1
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Src/: system_stm32f4xx.c
  group Application/User
    ../../Src/: main.c st7580_appli.c cube_hal_f4.c stm32f4xx_it.c
  group Drivers/BSP/X-NUCLEO-PLM01A1
    ../../../../../../Drivers/BSP/Components/ST7580/ST7580_Library/Src/: ST7580_Serial.c
    ../../: readme.txt
    ../../../../../../Drivers/BSP/X-NUCLEO-PLM01A1/: stm32_plm01a1.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xe.s
  group Drivers/BSP/STM32F4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo/: stm32f4xx_nucleo.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c
